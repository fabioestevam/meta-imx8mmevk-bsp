PACKAGECONFIG:remove:imx8mmevk = "etnaviv"
