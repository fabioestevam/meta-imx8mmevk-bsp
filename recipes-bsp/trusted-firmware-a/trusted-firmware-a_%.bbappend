COMPATIBLE_MACHINE_imx8mmevk = "imx8mmevk"
TFA_PLATFORM_imx8mmevk= "imx8mm"
TFA_BUILD_TARGET_imx8mmevk = "bl31"
